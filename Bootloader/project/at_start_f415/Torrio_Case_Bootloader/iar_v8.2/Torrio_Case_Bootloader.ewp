# IAR project Torrio_Case_Bootloader.ewp, settings and files
configuration Torrio_Case_Bootloader (ARM, debug)
  General.OGChipSelectEditMenu: AT32F415RBT7-7_v2 ArteryTek -AT32F415RBT7-7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415RCT7; USE_STDPERIPH_DRIVER; AT_START_F415_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32f415_board; ..\..\..\..\middlewares\usb_drivers\inc; ..\..\..\..\middlewares\usbd_class\custom_hid
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Torrio_Case_Bootloader.bin
  ILINK.IlinkOutputFile: Torrio_Case_Bootloader.out
  ILINK.IlinkIcfFile: Torrio_Case_Bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Torrio_Case_Bootloader_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AT32F415RCT7; USE_STDPERIPH_DRIVER; AT_START_F415_V1; DEBUG
  group bsp
    ../../../at32f415_board/: at32f415_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f415.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
  group firmware
    ../../../../libraries/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group readme
    ../: readme.txt
  group usbd_custom
    ../../../../middlewares/usbd_class/custom_hid/: custom_hid_class.c custom_hid_desc.c
  group usbd_drivers
    ../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group user
    ../src/: at32f415_clock.c at32f415_int.c Bootloader.c command.c file_system.c main.c usb.c version.c

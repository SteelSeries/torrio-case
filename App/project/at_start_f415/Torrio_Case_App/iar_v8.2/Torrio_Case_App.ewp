# IAR project Torrio_Case_App.ewp, settings and files
configuration Torrio_Case_App (ARM, debug)
  General.OGChipSelectEditMenu: AT32F415RBT7-7_v2 ArteryTek -AT32F415RBT7-7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415RCT7; USE_STDPERIPH_DRIVER; AT_START_F415_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32f415_board; ..\..\..\..\middlewares\usbd_class\custom_hid; ..\..\..\..\middlewares\usb_drivers\inc; ..\..\..\..\middlewares\i2c_application_library
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Torrio_Case_App.bin
  postbuild: _CRC32_Generate.bat
  ILINK.IlinkOutputFile: Torrio_Case_App.out
  ILINK.IlinkIcfFile: Torrio_Case_App.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Torrio_Case_App_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AT32F415RCT7; USE_STDPERIPH_DRIVER; AT_START_F415_V1; DEBUG
  postbuild: _CRC32_Generate_Debug.bat
  group bsp
    ../../../at32f415_board/: at32f415_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f415.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
  group firmware
    ../../../../libraries/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group i2c_application_library
    ../../../../middlewares/i2c_application_library/: i2c_application.c
  group readme
    ../: readme.txt
  group usbd_class
    ../../../../middlewares/usbd_class/custom_hid/: custom_hid_class.c custom_hid_desc.c
  group usbd_drivers
    ../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group user
    ../src/: adc.c app_fw_update.c at32f415_int.c battery.c Commands.c file_system.c i2c1.c init_pinout.c lid.c lighting.c main.c power_control.c sy8809.c sy8809_xsense.c system_clock.c system_state_manager.c task_scheduler.c timer2.c timer4.c timer5.c uart_comm_manager.c uart_command_queue.c uart_driver.c uart_interface.c uart_protocol.c usb.c version.c wdt.c
